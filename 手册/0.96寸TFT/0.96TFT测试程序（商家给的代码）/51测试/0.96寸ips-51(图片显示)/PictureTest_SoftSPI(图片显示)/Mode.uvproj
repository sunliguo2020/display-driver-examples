# Keil uVision project Mode.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: SPI +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./Program/: 282838p.c
